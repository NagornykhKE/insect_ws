Commit message: bug fixed

File: old/urdf/old.urdf (robot description, URDF)
Before this commit: robot old, 1 links, 0 joints
Links:
- added link world
Joints:
- added joint fix_joint: type fixed, parent world, child body_link, origin xyz=0 0 2 rpy=0 0 0
